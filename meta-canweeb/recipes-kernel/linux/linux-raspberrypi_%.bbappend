FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://preempt-rt.cfg \
    file://canweeb-robot.cfg \
"
